Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2015-07-30T16:11:17
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130709_2115(x64) - Exporter 3.12.0.0 - Alternate UI 2.12.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Jul 30 16:11:17 2015* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{C4BCAAD9-259F-4154-8D5C-2437CCEECB07}\ifc* Database version: 5507* Database creation date: Thu Jul 30 16:11:17 2015* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Jul 30 16:11:17 2015* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Jul 30 16:11:17 2015* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: ScorpioCRIB5_125mm, NBS_PineappleContracts_Mttrss_ScorpioCRIB5:ScorpioCRIB5_125mm:278609
In: Level 0
Type - Classification: Pr_40_50_06_50 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_PineappleContracts_Mattresses_ScorpioCRIB5_125mm; ManufacturerName: Pineapple Contracts; ManufacturerURL: www.pineapplecontracts.com; NBSCertification: www.nationalbimlibrary.com/cert/h5zt0ydk; NBSDescription: Mattresses; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 35-05-35/135; NBSTypeID: n/a; ProductInformation: www.pineapplecontracts.com/userfiles/file/Pineapple-main-brochure-2014.pdf; Revision: n/a; Version: 6; Uniclass2015Title: Mattresses; Uniclass2015Code: Pr_40_50_06_50; Uniclass2015Version: Products v1.5
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: Pr_40_50_06_50:Mattresses; CodePerformance: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Waterproof heat welded seams, easy wipe, ideal for seclusion; Finish: n/a; Grade: n/a; Manufacturer: www.pineapplecontracts.com; Material: Foam inner with havy-duty anti-vandal cover; ModelNumber: 1SOMS-001 (125 mm); 1SOMS-002 (180 mm); 1SOB-019 (330 mm); 1SOB-026 (535 mm); ModelReference: Scorpio CRIB 5; Name: Mattresses_ScorpioCRIB5_PineappleContracts; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Guarantee against manufacturing faults; WarrantyDurationLabor: n/a; WarrantyDurationParts: 7; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_FurnitureTypeCommon - Description: Mattress; IsBuiltIn: no; MainColor: Blue; NominalDepth: 125 mm; NominalHeight: 900 mm; NominalLength: 1800 mm
Type - NBS_Data - EnvironmentalProductDeclaration: n/a; FireRating: Source 5; IntegralAccessories: Integral pillow (180 mm thick only); ThicknessOptions: 125 mm, 180 mm, 330 mm, 535 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
